# location open source packages
#IMAGE_INSTALL += "qca-ssdk-hnat"
#IMAGE_INSTALL += "qca-ssdk-shell"
